Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T11:29:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 11:29:44 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{86097C0A-22E6-44FD-9B44-83F2037BFFD4}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 11:29:43 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 11:29:43 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 11:29:43 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR092 - GRANITO, Panca ARROW:0PAAR092 - GRANITO:134903
In: 0 - Piano Terra
Type - Material: GRANITO BIANCO SABBIATO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca ARROW
Type - Dati identità - BIM Name: ARROW; BIM Object Type: Panchine - Benches; Code: 0PAAR092; Designer: C + S ARCHITECTS; Family Name: ARROW; Nome del tipo: 0PAAR092 - GRANITO; URL Eng: https://www.bellitalia.net/en/products/benches/arrow/; URL Ita: https://www.bellitalia.net/prodotti/panchine/arrow/
Type - Dimensioni - Dimensions: 2550 mm x 1456 mm x 400 mm
Type - Generale - Descrizione Tecnica Famiglia: Panca mod. “ARROW” costituita da una seduta monolitica a forma di freccia. Vi è la possibilità di fissare la panca alla pavimentazione in essere per garantire maggiore stabilità e sicurezza al prodotto.; Descrizione Tecnica per Codice: PANCA ARROW IN GRANITO (COLORE A SCELTA) SABBIATO CON PIANO DI SEDUTA LEVIGATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Barre filettate; Fixings: threaded rods; Technical Description Family: The "ARROW" bench model consists of a monolithic seat in the shape of an arrow. There is the possibility to anchor the bench to the existing pavement to ensure greater stability and safety for the product.; Technical Description for Article: ARROW BENCH IN GRANITE (COLOR OF YOUR CHOICE) SANDBLASTED WITH POLISHED SEATING TOP WITH ANTI-DETERIOR PAINTING
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; MATERIALE SEDUTA: GRANITO BIANCO SABBIATO; Primary Material: White granite; Secondary Material: Granite stones
Type - Meccanica - Weight ( kg): 819 kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR092 - GRANITO
Altro - Famiglia: Panca ARROW: 0PAAR092 - GRANITO; Famiglia e tipo: Panca ARROW: 0PAAR092 - GRANITO; ID tipo: Panca ARROW: 0PAAR092 - GRANITO; Tipo: Panca ARROW: 0PAAR092 - GRANITO
Dimensioni - Area: 2.18825 m2; Volume: 0.33835 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
